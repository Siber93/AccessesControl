# Keil uVision project Project.uvprojx, settings and files
target STM32F401RE_Nucleo_SPWF01 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: STM32F401RE_Nucleo
  AfterMake: fromelf --bin -o STM32F401RE_Nucleo\STM32F401RE_Nucleo.bin STM32F401RE_Nucleo\STM32F401RE_Nucleo.axf
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,SPWF01,CONSOLE_UART_ENABLED
  c misc: --C99
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32f4xx\Include;..\..\..\..\..\..\Drivers\BSP\STM32f4xx-Nucleo;..\..\..\..\..\..\Drivers\STM32f4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW0xx1;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers\BSP\STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers\CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Server_Socket\MDK-ARM
    ./: startup_stm32f401xe.s
  group Drivers\BSP\X-NUCLEO-IDW0xx1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW0xx1/: stm32_spwf_wifi.c
  group Applications\Server_Socket\Src
    ../../Src/: main.c stm32_xx_it.c console.c stm32_xx_hal_msp.c ntp.c device_manager.c file_manager.c
  group Drivers\STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares\STM32_SPWF0xSy
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/: wifi_interface.c wifi_module.c wifi_module_spi.c wifi_module_uart_01.c wifi_module_uart_04.c
  group Middlewares\Utils
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/Utils/: wifi_globals.c spwf04WiFi.c ring_buffer.c event_buffer.c
target STM32F401RE_Nucleo_SPWF04_UART (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: STM32F401RE_Nucleo
  AfterMake: as above
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,SPWF04,CONSOLE_UART_ENABLED
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
target STM32F401RE_Nucleo_SPWF04_SPI (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: STM32F401RE_Nucleo
  AfterMake: as above
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,SPWF04
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
